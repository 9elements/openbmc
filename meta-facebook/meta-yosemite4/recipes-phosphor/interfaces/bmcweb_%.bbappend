EXTRA_OEMESON:append = " -Dbmcweb-logging=debug \
                         -Dredfish-dump-log=disabled \
                         -Dexperimental-redfish-multi-computer-system=enabled \
"
