FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += " \
file://0001-intelcpu-sensor-creates-intel-cpu-inventory.patch \
"
