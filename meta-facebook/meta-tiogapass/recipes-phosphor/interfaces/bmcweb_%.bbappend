
EXTRA_OEMESON:append = " -Dhttp-body-limit=65 -Dredfish-bmc-journal=enabled "
