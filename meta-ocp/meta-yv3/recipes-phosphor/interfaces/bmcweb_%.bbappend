EXTRA_OEMESON:append = " \
    -Dbmcweb-logging=debug \
    -Dredfish-dbus-log=enabled \
    -Dexperimental-redfish-multi-computer-system=enabled \
"
