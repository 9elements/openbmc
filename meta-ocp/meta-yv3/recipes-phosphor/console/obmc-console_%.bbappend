FILESEXTRAPATHS:append = "${PN}/files:"

SRC_URI += "\
