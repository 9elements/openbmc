IMAGE_INSTALL += " raw-power "
