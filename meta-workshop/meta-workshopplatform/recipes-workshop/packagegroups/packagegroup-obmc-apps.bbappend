RDEPENDS:${PN}-extras:append += " \
    hello-service \
    hello-cpp \
    phosphor-virtual-sensor \
"
