FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += " file://workshop.cfg "
